# Keil uVision project TSENSOR.uvprojx, settings and files
target TSENSOR (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TSENSOR +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ITEMP;..\HARDWARE\SMG;..\HARDWARE\ULN2003;..\HARDWARE\MAX31865;..\HARDWARE\NVIC;..\HARDWARE\GPS;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\IIC;..\HARDWARE\MQTT;..\HARDWARE\WIFI;..\HARDWARE\HMAC\inc;..\HARDWARE\24C02;..\HARDWARE\TIMER;..\HARDWARE\UART4;..\HARDWARE\DHT11
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/ULN2003/: ULN2003.c
    ../HARDWARE/MAX31865/: max31865.c
    ../HARDWARE/NVIC/: nvic.c
    ../HARDWARE/GPS/: gps.c
    ../HARDWARE/TIMER/: timer.c timer1.c timer2.c timer3.c timer4.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/MQTT/: mqtt.c
    ../HARDWARE/HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
    ../HARDWARE/24C02/: 24c02.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/DHT11/: dht11.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c
  group README
    ../: README.TXT
